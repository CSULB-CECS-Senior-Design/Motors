# Keil uVision project R2_ARC_Motors.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: R2_ARC_Motors +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: .\src;.\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: LED.c MotorControl.c MotorSetup.c MotorsMain.c PLL.c SPI.c startup.s Switches.c
    ./inc/: LED.h MotorControl.h MotorSetup.h PLL.h SPI.h Switches.h tm4c123gh6pm.h
